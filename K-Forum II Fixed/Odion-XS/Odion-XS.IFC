Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: XS.IFC
Time: 2016-10-31T12:57:15
Written by: SwIFC
Made in: SolidWorks 2016

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 mm

# IfcBuildingElementProxy: XS
In: Default Storey
Material: Steel
PSet_Type_Identity_Data - OmniClass Number: 23.80.70.11.14.21; OmniClass Title: Spots and Tracklight Specialties
PSet_Mass_Property - Mass Measure: 1001.14; Area Measure: 95424.4 m2; Volume Measure: 1001136 m3
